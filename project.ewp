# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: D:\stm32\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include; D:\stm32\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Include; $PROJ_DIR$; D:\stm32\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc; D:\stm32\STM32F4-Discovery_FW_V1.1.0\Utilities\STM32F4-Discovery
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: project5.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group EWARM
    D:/stm32/STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32F4-Discovery
    D:/stm32/STM32F4-Discovery_FW_V1.1.0/Utilities/STM32F4-Discovery/: stm32f4_discovery.c
    ../../Utilities/STM32F4-Discovery/: stm32f4_discovery_lis302dl.c
  group STM32F4xx_StdPeriph_Driver
    D:/stm32/STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_spi.c stm32f4xx_usart.c
  group User
    ./: IRsensor.c IRsensor.h moteurDC.c moteurDC.h
    src/: main.c
    D:/stm32/STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_dma.c
    D:/stm32/STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_adc.h stm32f4xx_dma.h stm32f4xx_tim.h
    D:/Useful_Files_STM32F4/: stm32f4xx_it.c
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_tim.c
    D:/stm32/STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
